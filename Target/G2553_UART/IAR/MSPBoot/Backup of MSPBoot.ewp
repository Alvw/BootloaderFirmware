# IAR project Backup of MSPBoot.ewp, settings and files
configuration BSLBased_UART (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: MSPBoot_BSL; MSPBoot_CI_UART
  ICC430.newCCIncludePaths: ..\..\Src\MSPBoot; ..\..\Src\MSPBoot\PI; ..\..\Src\MSPBoot\MI; ..\..\Src\MSPBoot\Comm; ..\..\Src\MSPBoot\AppMgr
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk_msp430G2553_UART_1KB_Boot.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../Src/MSPBoot/: cstartup.s43 main.c TI_MSPBoot_Common.h TI_MSPBoot_Config.h
  group Config
    Config/: lnk_msp430G2553_UART_1KB_Boot.xcl
  group Src/App_Manager
    ../../Src/MSPBoot/AppMgr/: Crc.c Crc.h TI_MSPBoot_AppMgr.c TI_MSPBoot_AppMgr.h TI_MSPBoot_VecRed_G2x53.c
  group Src/Communication_Interface
    ../../Src/MSPBoot/Comm/: TI_MSPBoot_CI.h
  group Src/Communication_Interface/NWK_APP
    ../../Src/MSPBoot/Comm/NWK_APP/: TI_MSPBoot_CI_NWK_APP.h TI_MSPBoot_CI_NWK_APP_BSL_UART.c
  group Src/Communication_Interface/PHY_DataLink
    ../../Src/MSPBoot/Comm/PHY_DataLink/: TI_MSPBoot_CI_PHYDL.h TI_MSPBoot_CI_PHYDL_USCI_UART.c
  group Src/Memory_Interface
    ../../Src/MSPBoot/MI/: TI_MSPBoot_MI.h TI_MSPBoot_MI_Flash.c
