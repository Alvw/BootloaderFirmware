# IAR project Backup of App2_MSPBoot.ewp, settings and files
configuration BSLBased_UART (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: SHARED_PI; MSPBoot_CI_UART
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: Config\lnk_msp430G2553_UART_1KB_App.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../Src/App2/: main2.c TI_MSPBoot_Mgr_CI.h TI_MSPBoot_Mgr_CI_G2.c TI_MSPBoot_Mgr_Vectors.h TI_MSPBoot_Mgr_Vectors_G2553.c
  group Config
    Config/: lnk_msp430G2553_UART_1KB_App.xcl
